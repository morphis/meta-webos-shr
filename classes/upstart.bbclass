PACKAGES =+ "${PN}-upstart"
FILES_${PN}-upstart = "${sysconfdir}/event.d/"
